IMAGE_INSTALL += "pipe-demo"
